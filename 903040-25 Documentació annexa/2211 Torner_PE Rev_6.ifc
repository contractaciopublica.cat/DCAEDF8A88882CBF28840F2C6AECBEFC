Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcBuildingElementProxy: Muro FA/ aplacat gelosia 1 40 (28)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro Gelosia 1
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
8 x SE- | 0,02
12 x SE- | 0,80
2 x M.3 | 0,00
2 x SE-1 | 0,80
SE- | 2,98
2 x SE- | 0,00
SE- | 2,90

# IfcBuildingElementProxy: Muro FA/ aplacat gelosia 2 40 (17)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro Gelosia 2
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
4 x SER 1.1 | -0,06
3 x SE- | -0,08
SER 3.1 | -0,24
M.9 | -0,08
M.8 | -0,08
3 x SE- | -0,10
SER 3.1 | -1,45
SER 3.1 | -1,42
SER 2.1 | -0,24
SER 3.1 | -0,19

# IfcBuildingElementProxy: Muro/ Trasdosado Simple 61 (15)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Panel de Yeso Laminado
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
6 x M.4
5 x M.5
4 x M.3

# IfcBuildingElementProxy: Muro/ Trasdosado Simple 90 85, M.4
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Panel de Yeso Laminado
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,03; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Muro/ Trasdosado Xapa 40 (8)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro Gelosia 1
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 201.AMB.EsEstructural
3 x SER 1.3 | Load-Bearing Element
3 x SER 1.3 | Non-Load-Bearing Element
SER 1.3.2 | Load-Bearing Element
SER 1.3.1 | Non-Load-Bearing Element

# IfcBuildingElementProxy: Muro/Tabique Pladur 10 100, REV 1.2
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Muro/Tabique Pladur 8 82 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Muro/Tabique Pladur 91 (4)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Muro/Tabique Pladur RF90+ Gelosia 106 (11)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
6 x M.4
5 x M.3

# IfcBuildingElementProxy: Puerta 25 (25)
In: Planta baixa
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 115.AMB.Nivell: Planta baixa
Name | Classification | 107.AMB.NomTipus | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status | 201.AMB.EsEstructural
3 x P - 002 | Puerta (Clasificación de ARCHICAD); 40.10.10.40 Fusteria interior (GuBIMclass CA); FIP (AMB) | AMB.FIP. | 0,00 | Existing | Undefined | 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 40.10.10.40; 105.AMB.ClassificacioDescripcio: Fusteria interior; 109.AMB.CodiTipus: FIP
4 x FIP 1 | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,00 | New | Non-Load-Bearing Element
FEP 3 | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,11 | New | Non-Load-Bearing Element
4 x SE- | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,80 | New | Non-Load-Bearing Element
2 x FEP 3 | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,02 | New | Non-Load-Bearing Element
4 x FEP 4 | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,00 | New | Non-Load-Bearing Element
FEP 3 | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,04 | New | Non-Load-Bearing Element
2 x SE- | Puerta (Clasificación de ARCHICAD) | AMB.. | -0,02 | New | Non-Load-Bearing Element
SE- | Puerta (Clasificación de ARCHICAD) | AMB.. | -0,07 | New | Non-Load-Bearing Element
SE- | Puerta (Clasificación de ARCHICAD) | AMB.. | -0,19 | New | Non-Load-Bearing Element
SER 6 | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,01 | New | Non-Load-Bearing Element
FIM-1 | Puerta (Clasificación de ARCHICAD) | AMB.. | 0,02 | New | Non-Load-Bearing Element

# IfcBuildingElementProxy: Puerta Corredera Empotrada 25, FIP 3
In: Planta baixa
Classification: Puerta (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,02; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Puerta Doble 25 (4)
In: Planta baixa
Classification: Puerta (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
FIP 2 | 0,02
3 x FIP 2 | 0,00

# IfcBuildingElementProxy: Puerta Doble Corredera Exterior 25 (2)
In: Planta baixa
Classification: Puerta (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
FEP 2.1 | 0,05
FEP 2.2 | 0,00

# IfcBuildingElementProxy: Puerta Metal Doble 25, P - 011
In: Planta baixa
Classification: Puerta (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,25; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: RHS100X100X5 100 x 100 (8)
In: Planta baixa
Classification: Pilar (Clasificación de ARCHICAD); Material: Acero - Blanco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
4 x SE- | 0,00
4 x SE- | 0,16

# IfcBuildingElementProxy: Tierra Esquematic (3)
In: Planta baixa
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Tierra Esquematic
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: -0,26; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
2 x TR - 001
TR - 002

# IfcBuildingElementProxy: UPE100 55 x 100, Viga-005
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD); Material: Acero - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,41; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Ventana 25 (206)
Classification: Ventana (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
2 x FEP 2.1 | Planta baixa | Planta baixa | 0,07 | New
2 x FEP 2.2 | Planta baixa | Planta baixa | 0,03 | New
FE-16 | Planta primera | Planta primera | 0,07 | Existing
54 x FE-16 | Planta primera | Planta primera | 0,33 | Existing
26 x FE-16 | Planta primera | Planta primera | 2,08 | Existing
26 x FE-16 | Planta primera | Planta coberta | 3,65 | Existing
26 x FE-16 | Planta primera | Planta coberta | 5,22 | Existing
5 x FE-16 | Planta primera | Planta primera | 0,09 | New
12 x FE-16 | Planta primera | Planta primera | 0,08 | New
17 x FE-16 | Planta primera | Planta primera | 1,82 | New
17 x FE-16 | Planta primera | Planta coberta | 3,56 | New
17 x FE-16 | Planta primera | Planta coberta | 5,33 | New
FE-16 | Planta primera | Planta primera | 0,09 | Existing

# IfcBuildingElementProxy: Ventana Mercado 1 (55)
In: Planta baixa
Classification: Ventana (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
15 x FE-15 | 2,46 | Existing
12 x FE-15 | 2,46 | New
13 x FE-15 | 2,50 | Existing
2 x FEF 1 | 2,50 | Existing
12 x FE-15 | 2,50 | New
FEF 1 | 2,50 | New

# IfcBuildingElementProxy: Vidrio (16)
In: Planta baixa
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Vidrio
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
8 x FEP-1
8 x FE-

# IfcBuildingElementProxy: Vidrio Espejo 10, EQP 1
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Vidrio Espejo
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,93; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: WC Discapacitados 25, APS 4
In: Planta baixa
Classification: Elemento de Flujo de Distribución (Clasificación de ARCHICAD); 60.10.10.10 Inodors (GuBIMclass CA); APS (AMB)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 104.AMB.ClassificacioCodi: 60.10.10.10; 105.AMB.ClassificacioDescripcio: Inodors; 107.AMB.NomTipus: AMB.APS.; 109.AMB.CodiTipus: APS; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,03; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: heb 200 400 x 200 (2)
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,35; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: ipe 300 (1) 245 x 300 (12)
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,35; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
8 x Viga-011
4 x Viga-012
