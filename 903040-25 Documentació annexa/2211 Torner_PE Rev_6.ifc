Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0, SurfaceGeometryAddOnView, SpaceBoundary2ndLevelAddOnView], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Visible Only], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: On], Option [ARCHICAD Zone Categories as IFC Space classification data: On], Option [Element Classifications: On]
File name: H:\Dropbox (Personal)\K·P\1-PROJECTES\2211 MERCAT TORNER\2211-04 PE Rev\7-IFC\2211 Torner_PE Rev_6.ifc
Time: 2024-05-30T10:27:41
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD 25.0.0 INT FULL Windows version (IFC add-on version: 4013 INT FULL).
Authorization: The authorising person

# IfcProject, PROJECTE D’EXECUCIÓ, ESTUDI DE SEGURETAT I SALUT I POSTERIOR DIRECCIÓ DE LES OBRES DE L’ADEQUACIÓ DEL MERCAT DE TORNER, A BADALONA.
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905305/21; 004.AMB.FaseProjecte: Document bàsic.; 006.AMB.UsEdifici: Bucs d’assaig municipal; 007.AMB.ModelDisciplina: Rehabilitació; 008.AMB.Adreca: C/ les Malves s/n; 009.AMB.Municipi: Montacada i Reixac; 010.AMB.AutorProjecte: Pol Femenias Ureña; 011.AMB.AutorProjecte2: Anna Padilla Corcho; 012.AMB.AutorProjecte3: Valentin Kokudev; 005.AMB.NomEdifici: Nau Brigada; 003.AMB.NomProjecte: Nau de l’antiga brigada

# IfcSite, Site
RefLatitude: 41, 38, 23, 900000; RefLongitude: 2, 13, 25, 900000; RefElevation: 5.9 m

# IfcBuildingStorey (4)
In: Building
Name | Elevation (m)
Planta soterrani | -3
Planta baixa | 0
Planta primera | 3.4
Planta coberta | 6.4

# IfcSpace: Otro Uso (3)
In: Planta baixa
InteriorOrExteriorSpace: INTERNAL; Classification: Espacio (Clasificación de ARCHICAD); 7 Otro Uso
Pset_SpaceCommon - Reference: Espacio; Category: Otro Uso
Pset_SpaceOccupancyRequirements - AreaPerOccupant: 6 m2
2 AMB.Caracteristiques - 212.AMB.Us: Otro Uso
Name | LongName = 118.AMB.Zona | OccupancyNumber | 106.AMB.Nom | 108.AMB.Codi | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
1 | Safareig | 0 | AMB.Zona.Safareig | AMB.Zona.1 | New
 | Parada | 2 | AMB.Zona.Parada | AMB.Zona. | Existing
2 | Ch1 | 0 | AMB.Zona.Ch1 | AMB.Zona.2 | New

# IfcBuildingElementPart (260)
Name | In | Material
55 x Acero - Blanco | Planta baixa | Acero - Blanco
55 x Vidrio | Planta baixa | Vidrio
24 x Panel de Yeso Laminado | Planta baixa | Panel de Yeso Laminado
16 x Panel de Yeso Laminado - Impermeable | Planta baixa | Panel de Yeso Laminado - Impermeable
22 x Enlucido - Yeso | Planta baixa | Enlucido - Yeso
26 x Ladrillo Revoco | Planta baixa | Ladrillo Revoco
26 x Revoco - Exterior | Planta baixa | Revoco - Exterior
4 x Aislamiento - Mineral Duro | Planta baixa | Aislamiento - Mineral Duro
32 x Hierro | Planta primera | Hierro

# IfcBuildingElementProxy: Acabado Zocalo 50 (43)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Acabado Zocalo
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
14 x M.0 | -0,10 | New
3 x M.5 | -0,10 | New
5 x M.6 | -0,10 | New
5 x M.8 | -0,10 | New
2 x M.9 | -0,10 | New
3 x M.1 | -0,10 | New
3 x M.2 | -0,10 | New
M.3 | 0,00 | Existing
2 x M.4 | -0,10 | New
M.7 | -0,10 | New
2 x M.3 | -0,10 | New
M.8 | -0,10 | Existing
M.8 | 0,00 | New

# IfcBuildingElementProxy: Acero - Blanco, TR - 037
In: Planta baixa
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Acero - Blanco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,10; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Acero - Blanco 50 x 50, Viga-005
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD); Material: Acero - Blanco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,31; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Acero - Chapado (7)
In: Planta baixa
Material: Acero - Chapado
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB.LLU.; 109.AMB.CodiTipus: LLU; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Classification | 116.AMB.SeparacioNivell
LLU 4 | Geometría del Terreno (Clasificación de ARCHICAD); 70.40.10 Enllumenat (GuBIMclass CA); LLU (AMB) | 2,53 | 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.10; 105.AMB.ClassificacioDescripcio: Enllumenat
4 x LLU 4 | Geometría del Terreno (Clasificación de ARCHICAD); LLU (AMB) | 2,58
LLU 4 | Geometría del Terreno (Clasificación de ARCHICAD); 70.40.10 Enllumenat (GuBIMclass CA); LLU (AMB) | 2,58 | 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.10; 105.AMB.ClassificacioDescripcio: Enllumenat
PCRI | Geometría del Terreno (Clasificación de ARCHICAD); 70.40.10 Enllumenat (GuBIMclass CA); LLU (AMB) | 1,03 | 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 70.40.10; 105.AMB.ClassificacioDescripcio: Enllumenat

# IfcBuildingElementProxy: Acero - Color (5)
In: Planta baixa
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Acero - Color
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 3,05; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Acero - Estructural (2)
In: Planta baixa
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Acero - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
TR - 060 | -0,15
TR - 062 | 1,70

# IfcBuildingElementProxy: Acero - Estructural 43 (10)
In: Planta primera
Classification: Cubierta (Clasificación de ARCHICAD); Material: Acero - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
6 x CUB - 005 | 2,62
4 x CUB - 005 | 2,60

# IfcBuildingElementProxy: Acero - Inoxidable (12)
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Acero - Inoxidable
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
2 x TR - 050 | Planta soterrani | Planta soterrani | 2,98 | Existing
TR - 050 | Planta soterrani | Planta soterrani | 2,97 | Existing
TR - 050 | Planta soterrani | Planta soterrani | 3,00 | Existing
TR - 050 | Planta soterrani | Planta soterrani | 3,03 | Existing
SE- | Planta baixa | Planta baixa | 0,51 | New
SE- | Planta baixa | Planta baixa | -0,34 | New
2 x SE- | Planta baixa | Planta baixa | 0,58 | New
EQP 2 | Planta baixa | Planta baixa | 0,56 | New
SE- | Planta baixa | Planta baixa | 0,59 | New
EQP 2 | Planta baixa | Planta baixa | 0,55 | New

# IfcBuildingElementProxy: Acero - Inoxidable 180, M.6
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Acero - Inoxidable
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 3,35; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Acero - Inoxidable 20 (3)
Classification: Muro (Clasificación de ARCHICAD); Material: Acero - Inoxidable
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell
2 x M.3 | Planta baixa | Planta baixa | 0,01
M.3 | Planta primera | Planta primera | -0,84

# IfcBuildingElementProxy: Acero - Inoxidable 30 (5)
In: Planta primera
Classification: Muro (Clasificación de ARCHICAD); Material: Acero - Inoxidable
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
4 x M.3 | -0,85
M.3 | -0,82

# IfcBuildingElementProxy: Acero - Inoxidable 50 (16)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Acero - Inoxidable
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
8 x M.3 | 0,00
M.3 | -0,03
2 x M.3 | 0,04
3 x M.3 | 0,03
M.3 | 0,01
M.3 | 0,06

# IfcBuildingElementProxy: Acero Sección T 30 x 80 (2)
In: Planta baixa
Classification: Viga (Clasificación de ARCHICAD); Material: Acero
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
EQP 2 | 0,85
EQP 2 | 0,89

# IfcBuildingElementProxy: Acero Sección T 60 x 80 (2)
In: Planta baixa
Classification: Viga (Clasificación de ARCHICAD); Material: Acero
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
EQP 2 | 0,85
EQP 2 | 0,89

# IfcBuildingElementProxy: Acero Tubo Rectangular 40 x 80, EQP 2
In: Planta baixa
Classification: Viga (Clasificación de ARCHICAD); Material: Acero - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,85; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Aluminio 200 x 160 (4)
In: Planta baixa
Classification: Viga (Clasificación de ARCHICAD); Material: Aluminio
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 2,87; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Bajante 25, FM-9
In: Planta baixa
Classification: Accesorios Varios (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,01; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Baldosa - Mural 10x10 10 (10)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Baldosa - Mural 10x10
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,03; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
7 x REV 6
2 x M.5
REV 7

# IfcBuildingElementProxy: Baldosa - Mural 20x20 10 (14)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Baldosa - Mural 20x20
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell | 201.AMB.EsEstructural
3 x REV 1.2 | 0,04 | Non-Load-Bearing Element
REV 1.2 | 2,65 | Non-Load-Bearing Element
REV 1.2 | 0,00 | Non-Load-Bearing Element
REV 1.2 | 0,05 | Non-Load-Bearing Element
REV 1.2 | 2,71 | Non-Load-Bearing Element
REV 1.2 | 0,06 | Non-Load-Bearing Element
M.4 | 2,69 | Load-Bearing Element
REV 1.2 | 2,70 | Non-Load-Bearing Element
REV 1.2 | 0,03 | Non-Load-Bearing Element
2 x REV 1.2 | 2,69 | Non-Load-Bearing Element
REV 1.2 | 2,92 | Non-Load-Bearing Element

# IfcBuildingElementProxy: Baldosa - Mural 20x25 10 (6)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Baldosa - Mural 20x25
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
3 x M.4 | 2,44
M.4 | 2,40
M.4 | 2,45
M.4 | 2,46

# IfcBuildingElementProxy: Baldosa - Mural Tira 6x15 10 (6)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Baldosa - Mural Tira 6x15
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell | 201.AMB.EsEstructural
M.4 | 2,85 | Load-Bearing Element
REV 3.2 | 2,90 | Load-Bearing Element
REV 3.2 | 2,91 | Load-Bearing Element
M.4 | 2,89 | Load-Bearing Element
2 x REV 3.2 | 2,89 | Non-Load-Bearing Element

# IfcBuildingElementProxy: Cámara de Aire 50 x 80 (8)
In: Planta baixa
Classification: Pilar (Clasificación de ARCHICAD); Material: Acero - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,16; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Encimera Multi-Fregadero 25, APS4 + EQP2
In: Planta baixa
Classification: Elemento de Flujo de Distribución (Clasificación de ARCHICAD); 60.10.10.10 Inodors (GuBIMclass CA); APS (AMB)
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.APS.Sanitarios; 103.AMB.Classificacio: GuBim Class v1.2; 104.AMB.ClassificacioCodi: 60.10.10.10; 105.AMB.ClassificacioDescripcio: Inodors; 109.AMB.CodiTipus: APS; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,01; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Enlucido - Yeso (15)
In: Planta baixa
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Enlucido - Yeso
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
SE- | 0,07
8 x LLU 3 | 2,14
6 x LLU 3 | 2,17

# IfcBuildingElementProxy: Enlucido - Yeso 10, REV 1.2
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Enlucido - Yeso
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 2,96; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Enlucido - Yeso 25 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Enlucido - Yeso
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
FIM 1 | -0,01
FIM 1 | 0,02

# IfcBuildingElementProxy: Extintor 25 (9)
In: Planta baixa
Classification: Sustituto de Elemento Constructivo (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
5 x FM-9 | 0,26 | New
2 x FM-9 | 0,01 | Existing
FM-9 | 1,49 | Existing
FM-9 | 0,01 | New

# IfcBuildingElementProxy: Fals sostre lavabo 45 (2)
In: Planta baixa
Classification: Forjado (Clasificación de ARCHICAD); Material: Panel de Yeso Laminado
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
F.1 | 2,96
F.1 | 2,95

# IfcBuildingElementProxy: GENÉRICO - ESTRUCTURAL D200 (8)
In: Planta baixa
Classification: Pilar (Clasificación de ARCHICAD); Material: GENÉRICO - ESTRUCTURAL
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: HEA100 100 x 96 (17)
In: Planta baixa
Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Classification | 116.AMB.SeparacioNivell | 201.AMB.EsEstructural
4 x SER 1.5 | Pilar (Clasificación de ARCHICAD) | 0,02 | Undefined
3 x SER 1.5 | Viga (Clasificación de ARCHICAD) | 3,30 | Load-Bearing Element
4 x SER 1.5 | Pilar (Clasificación de ARCHICAD) | 0,00 | Undefined
2 x SER 2.4 | Viga (Clasificación de ARCHICAD) | 3,30 | Load-Bearing Element
2 x SER-3.4 | Pilar (Clasificación de ARCHICAD) | 0,06 | Undefined
2 x SER-2.4 | Pilar (Clasificación de ARCHICAD) | 0,06 | Undefined

# IfcBuildingElementProxy: HEB100 100 x 100 (2)
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD); Material: Acero - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,50; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: HEB140 (1) 161 x 180 (4)
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
Viga-012 | 3,05
2 x Viga-011 | -0,17
Viga-012 | -0,17

# IfcBuildingElementProxy: HEB140 140 x 140 (2)
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,42; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro (48)
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
8 x SER 1.4 | Planta baixa | Planta baixa | 0,00 | New
8 x SER 1.4 | Planta baixa | Planta baixa | -0,04 | New
2 x SER 1.4 | Planta baixa | Planta baixa | 2,76 | New
12 x SER 2.3 | Planta baixa | Planta baixa | 0,00 | New
12 x SER 3.3 | Planta baixa | Planta baixa | 0,00 | New
TR - 047 | Planta baixa | Planta baixa | 2,82 | New
3 x TR - 047 | Planta baixa | Planta baixa | 2,82 | Existing
2 x TR - 059 | Planta primera | Planta primera | -0,15 | Existing

# IfcBuildingElementProxy: Hierro 10 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,04; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro 100 (3)
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
M.2 | Planta baixa | Planta baixa | 3,25 | Existing
M.8 | Planta primera | Planta primera | 0,05 | New
M.8 | Planta primera | Planta primera | 0,00 | Existing

# IfcBuildingElementProxy: Hierro 150, M.8
In: Planta primera
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,15; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Hierro 18 (2)
Classification: Forjado (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell
F.1 | Planta baixa | Planta baixa | 2,84
SER 1.2 | Planta primera | Planta primera | -0,64

# IfcBuildingElementProxy: Hierro 190 (2)
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell
M.2 | Planta baixa | Planta baixa | 3,10
M.1 | Planta primera | Planta primera | -0,38

# IfcBuildingElementProxy: Hierro 20 (6)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
M.2 | 3,25 | Existing
2 x M.2 | 3,25 | New
M.2 | 3,05 | New
M.8 | 3,05 | New
SER 3.1 | -0,06 | New

# IfcBuildingElementProxy: Hierro 200 (2)
Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | Classification | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 201.AMB.EsEstructural
M.0 | Planta baixa | Muro (Clasificación de ARCHICAD) | Planta baixa | -0,15 | Load-Bearing Element
F.1 | Planta primera | Forjado (Clasificación de ARCHICAD) | Planta primera | -0,35 | Non-Load-Bearing Element

# IfcBuildingElementProxy: Hierro 250 (10)
In: Planta baixa
Classification: Forjado (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 3,05; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro 30 (4)
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell
2 x EQP 3 | Planta baixa | Planta baixa | 2,76
EQP | Planta baixa | Planta baixa | 2,76
M.5 | Planta primera | Planta primera | -0,52

# IfcBuildingElementProxy: Hierro 300 (12)
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell
M.1 | Planta baixa | Planta baixa | 3,25
2 x M.1 | Planta primera | Planta primera | -0,15
6 x M.1 | Planta primera | Planta primera | -0,38
M.9 | Planta primera | Planta primera | -0,15
M.9 | Planta primera | Planta primera | -0,38
M.0 | Planta primera | Planta primera | -0,38

# IfcBuildingElementProxy: Hierro 350, F.1
In: Planta baixa
Classification: Forjado (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 3,05; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro 420, M.1
In: Planta primera
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,38; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro 440, M.1
In: Planta primera
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,38; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro 460 (2)
In: Planta primera
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,38; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro 50 (12)
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
M.5 | Planta baixa | Planta baixa | -0,04 | New
FEP 2.2 | Planta baixa | Planta baixa | 0,00 | New
2 x M.3 | Planta primera | Planta primera | -0,05 | Existing
8 x M.3 | Planta primera | Planta primera | 0,00 | Existing

# IfcBuildingElementProxy: Hierro 8 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,06; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro 98 (2)
In: Planta primera
Classification: Forjado (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,35; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hierro D220 (12)
In: Planta baixa
Classification: Pilar (Clasificación de ARCHICAD); Material: Hierro
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
11 x SE- | 3,17
SE- | 3,12

# IfcBuildingElementProxy: Hierro Gelosia 1 10 (14)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro Gelosia 1
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status | 201.AMB.EsEstructural
3 x SER 1.3 | 0,00 | New | Load-Bearing Element
3 x SER 1.3 | 0,02 | Existing | Non-Load-Bearing Element
3 x SER 1.3 | 0,02 | New | Load-Bearing Element
5 x SER 1.3 | 0,00 | Existing | Non-Load-Bearing Element

# IfcBuildingElementProxy: Hierro Gelosia 1 18 (4)
In: Planta baixa
Classification: Forjado (Clasificación de ARCHICAD); Material: Hierro Gelosia 1
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
SER 3.2 | 2,86
SER 1.2 | 2,78
SER 2.2 | 2,86
F.1 | 2,83

# IfcBuildingElementProxy: Hierro Gelosia 1 20 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro Gelosia 1
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
SER 3.2 | 2,84
M.6 | 2,83

# IfcBuildingElementProxy: Hierro Gelosia 1 70, SER 1.2
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Hierro Gelosia 1
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 2,76; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hormigón 120, F.3
In: Planta primera
Classification: Forjado (Clasificación de ARCHICAD); Material: Hormigón
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,15; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Hormigón 1350 (4)
In: Planta baixa
Classification: Forjado (Clasificación de ARCHICAD); Material: Hormigón
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 1,35; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Hormigón 160, M.3
In: Planta soterrani
Classification: Muro (Clasificación de ARCHICAD); Material: Hormigón
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta soterrani; 116.AMB.SeparacioNivell: 2,80; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Hormigón Armado - Estructural (50)
Material: Hormigón Armado - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Classification | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 109.AMB.CodiTipus | 115.AMB.Nivell | 116.AMB.SeparacioNivell
28 x LLU 2 | Planta baixa | Geometría del Terreno (Clasificación de ARCHICAD); 70.40.10 Enllumenat (GuBIMclass CA); LLU (AMB) | 70.40.10 | Enllumenat | AMB.LLU. | LLU | Planta baixa | 2,95
8 x LLU 1 | Planta baixa | Geometría del Terreno (Clasificación de ARCHICAD); LLU (AMB) |  |  | AMB.LLU. | LLU | Planta baixa | 2,76
TR - 067 | Planta baixa | Geometría del Terreno (Clasificación de ARCHICAD) |  |  | AMB.. |  | Planta baixa | 1,94
4 x LLU 1 | Planta baixa | Geometría del Terreno (Clasificación de ARCHICAD); LLU (AMB) |  |  | AMB.LLU. | LLU | Planta baixa | 2,85
TR - 038 | Planta primera | Geometría del Terreno (Clasificación de ARCHICAD) |  |  | AMB.. |  | Planta primera | -0,18
4 x TR - 038 | Planta primera | Geometría del Terreno (Clasificación de ARCHICAD) |  |  | AMB.. |  | Planta primera | -0,20
TR - 038 | Planta primera | Geometría del Terreno (Clasificación de ARCHICAD) |  |  | AMB.. |  | Planta primera | 0,00
2 x TR - 039 | Planta coberta | Geometría del Terreno (Clasificación de ARCHICAD) |  |  | AMB.. |  | Planta coberta | 2,95
TR - 041 | Planta coberta | Geometría del Terreno (Clasificación de ARCHICAD) |  |  | AMB.. |  | Planta coberta | 10,34

# IfcBuildingElementProxy: IPE100 55 x 100 (146)
In: Planta baixa
Classification: Viga (Clasificación de ARCHICAD); Material: Acero - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
133 x Viga-005 | 3,05 | Existing
Viga-005 | 3,05 | New
12 x Viga-005 | 5,70 | Existing

# IfcBuildingElementProxy: IPE120 64 x 120 (2)
In: Planta baixa
Classification: Viga (Clasificación de ARCHICAD); Material: Acero
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 2,94; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: IPE140 73 x 140 (2)
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD); Material: Acero
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,52; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: IPE180(1) 201 x 180 (2)
In: Planta primera
Classification: Viga (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta primera; 116.AMB.SeparacioNivell: -0,38; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
Viga-011
Viga-012

# IfcBuildingElementProxy: IPE80 46 x 80 (32)
In: Planta baixa
Classification: Viga (Clasificación de ARCHICAD); Material: Hormigón
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 3,05; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Incendis (12)
In: Planta baixa
Classification: Geometría del Terreno (Clasificación de ARCHICAD); Material: Incendis
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Non-Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
3 x SE- | 1,61
3 x SE- | 3,35
3 x SE- | 1,62
2 x TR - 058 | 1,49
TR - 058 | 1,43

# IfcBuildingElementProxy: Ladrillo 140 (5)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
2 x M.5 | Existing
3 x M.5 | New

# IfcBuildingElementProxy: Ladrillo 70 (4)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
M.6
3 x M.5

# IfcBuildingElementProxy: Ladrillo Revoco 100 (9)
Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | In | Classification | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
M.2 | Planta baixa | Muro (Clasificación de ARCHICAD) | Planta baixa | 3,25 | Existing
2 x M.8 | Planta baixa | Muro (Clasificación de ARCHICAD) | Planta baixa | 15,02 | Existing
M.2 | Planta baixa | Muro (Clasificación de ARCHICAD) | Planta baixa | 3,25 | New
M.8 | Planta primera | Muro (Clasificación de ARCHICAD) | Planta primera | 0,00 | Existing
2 x F.3 | Planta primera | Forjado (Clasificación de ARCHICAD) | Planta primera | -0,30 | Existing
2 x F.2 | Planta primera | Forjado (Clasificación de ARCHICAD) | Planta primera | -0,30 | Existing

# IfcBuildingElementProxy: Ladrillo Revoco 120 (8)
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | 115.AMB.Nivell
5 x M.0 | Planta soterrani | Planta soterrani
M.1 | Planta soterrani | Planta soterrani
M.0 | Planta baixa | Planta baixa
M.1 | Planta baixa | Planta baixa

# IfcBuildingElementProxy: Ladrillo Revoco 140 (18)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
3 x M.5 | 2,90 | New
6 x M.5 | 0,00 | Existing
2 x M.7 | 0,00 | Existing
6 x M.5 | 0,00 | New
M.5 | 2,90 | Existing

# IfcBuildingElementProxy: Ladrillo Revoco 150 (9)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
4 x M.8 | Existing
M.3 | Existing
4 x M.4 | New

# IfcBuildingElementProxy: Ladrillo Revoco 160 (3)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
M.2 | 0,00
M.3 | 3,02
M.3 | -0,10

# IfcBuildingElementProxy: Ladrillo Revoco 190 (37)
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | In | 115.AMB.Nivell | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
M.5 | Planta soterrani | Planta soterrani | 0,00 | Existing
M.3 | Planta soterrani | Planta soterrani | 0,00 | Existing
12 x M.2 | Planta baixa | Planta baixa | -0,10 | Existing
2 x M.2 | Planta baixa | Planta baixa | 0,00 | Existing
M.3 | Planta baixa | Planta baixa | 0,00 | Existing
M.5 | Planta baixa | Planta baixa | 2,90 | New
2 x M.2 | Planta baixa | Planta baixa | 2,90 | New
M.7 | Planta baixa | Planta baixa | 0,00 | Existing
3 x M.2 | Planta baixa | Planta baixa | 2,98 | New
2 x M.3 | Planta baixa | Planta baixa | -0,10 | Existing
M.3 | Planta baixa | Planta baixa | 2,90 | New
M.4 | Planta baixa | Planta baixa | 2,90 | New
M.6 | Planta baixa | Planta baixa | 2,89 | New
M.7 | Planta baixa | Planta baixa | 2,89 | New
M.8 | Planta baixa | Planta baixa | 0,00 | Existing
M.3 | Planta baixa | Planta baixa | 3,12 | New
M.4 | Planta baixa | Planta baixa | 0,00 | Existing
M.5 | Planta baixa | Planta baixa | 0,00 | Existing
M.6 | Planta baixa | Planta baixa | 0,00 | Existing
M.8 | Planta baixa | Planta baixa | 2,90 | New
M.3 | Planta baixa | Planta baixa | 3,02 | Existing

# IfcBuildingElementProxy: Ladrillo Revoco 200 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
M.9
M.2

# IfcBuildingElementProxy: Ladrillo Revoco 220 (7)
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | 115.AMB.Nivell
3 x M.0 | Planta soterrani | Planta soterrani
2 x M.1 | Planta soterrani | Planta soterrani
M.2 | Planta soterrani | Planta soterrani
M.0 | Planta baixa | Planta baixa

# IfcBuildingElementProxy: Ladrillo Revoco 290 (4)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 2,98
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
M.2 | New
M.3 | Existing
M.2 | Existing
M.4 | New

# IfcBuildingElementProxy: Ladrillo Revoco 30, F.3
In: Planta baixa
Classification: Forjado (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 1,50; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Ladrillo Revoco 320 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: -0,10; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
M.2
M.3

# IfcBuildingElementProxy: Ladrillo Revoco 350 (45)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
16 x M.2 | -0,10 | Existing
M.2 | 0,00 | Existing
M.3 | 0,00 | Existing
3 x M.2 | 2,98 | New
9 x M.8 | 0,00 | Existing
M.7 | 0,00 | Existing
M.2 | 2,90 | New
M.3 | 2,90 | New
M.4 | 2,90 | New
M.5 | 2,90 | New
M.6 | 2,90 | New
2 x M.2 | 0,00 | New
M.4 | 0,00 | Existing
M.5 | 0,00 | Existing
M.6 | 0,00 | Existing
M.7 | 2,90 | New
M.2 | 2,98 | Existing
M.8 | 2,90 | Existing
M.8 | 2,90 | New

# IfcBuildingElementProxy: Ladrillo Revoco 400, M.7
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Ladrillo Revoco 450 (4)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
2 x M.2 | 0,00 | Existing
M.2 | 2,90 | New
M.2 | 2,90 | Existing

# IfcBuildingElementProxy: Ladrillo Revoco 480 (5)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
3 x M.2 | 0,00
M.8 | 0,00
M.2 | 2,98

# IfcBuildingElementProxy: Ladrillo Revoco 500, M.4
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Ladrillo Revoco 505, M.2
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Ladrillo Revoco 510, M.2
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Ladrillo Revoco 620 (10)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
7 x M.4 | 0,00
2 x M.4 | -0,05
M.4 | 2,98

# IfcBuildingElementProxy: Ladrillo Revoco 70 (9)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
M.5 | 0,00
2 x M.6 | 0,00
M.2 | 0,00
M.3 | 0,00
2 x M.8 | 0,00
2 x M.8 | -0,10

# IfcBuildingElementProxy: Ladrillo Revoco 80 (20)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
3 x M.9 | 0,00 | Existing
6 x M.8 | 0,00 | Existing
M.2 | 3,12 | Existing
M.1 | 0,00 | New
5 x M.9 | 0,00 | New
4 x M.0 | 0,00 | New

# IfcBuildingElementProxy: Ladrillo Revoco interior 100, M.8
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco interior
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Ladrillo Revoco interior 150 (10)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco interior
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa
Name | 116.AMB.SeparacioNivell | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status | 201.AMB.EsEstructural
M.0 | 0,00 | New | Load-Bearing Element
3 x REV 1.2 | 0,00 | New | Non-Load-Bearing Element
M.8 | -0,03 | Existing | Load-Bearing Element
3 x M.8 | 0,00 | Existing | Load-Bearing Element
M.8 | -0,12 | Existing | Load-Bearing Element
REV 1.2 | -0,05 | Existing | Non-Load-Bearing Element

# IfcBuildingElementProxy: Ladrillo Revoco interior 620 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco interior
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 116.AMB.SeparacioNivell
M.4 | -0,03
M.4 | 0,00

# IfcBuildingElementProxy: Ladrillo Revoco interior 70 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco interior
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
M.0
M.3

# IfcBuildingElementProxy: Ladrillo Revoco interior 80 (2)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Ladrillo Revoco interior
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: -0,05; 119.AMB.FaseCreacio: Existing; 120.AMB.FaseEnderroc: Existing
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Lavabo 25, APS2+APS3
In: Planta baixa
Classification: Elemento de Flujo de Distribución (Clasificación de ARCHICAD); 60.10.10.10 Inodors (GuBIMclass CA); APS (AMB)
1 AMB.Identificacio - 107.AMB.NomTipus: AMB.APS.Sanitarios; 103.AMB.Classificacio: GuBim Class v1.2; 104.AMB.ClassificacioCodi: 60.10.10.10; 105.AMB.ClassificacioDescripcio: Inodors; 109.AMB.CodiTipus: APS; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: -0,12; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Manguera Incendios 25 (6)
In: Planta baixa
Classification: Sustituto de Elemento Constructivo (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell
3 x FM-9 | 1,32
FM-9 | 1,25
2 x FM-9 | 1,30

# IfcBuildingElementProxy: Motllura guix 96 x 298 (13)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD); Material: Bloque de Mampostería - Estructural
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 3,05
Name | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status | 201.AMB.EsEstructural
4 x REV 4.2 | New | Non-Load-Bearing Element
REV 4.2 | Existing | Non-Load-Bearing Element
5 x REV 4.1 | Existing | Non-Load-Bearing Element
M.4 | Existing | Load-Bearing Element
M.2 | Existing | Load-Bearing Element
M.3 | Existing | Load-Bearing Element

# IfcBuildingElementProxy: Muro FA / Gero simple 150 (22)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 116.AMB.SeparacioNivell: 0,00
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Load-Bearing Element
Name | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc = Renovation Status
5 x M.5 | Existing
4 x M.6 | New
8 x M.5 | New
4 x M.4 | New
M.8 | Existing

# IfcBuildingElementProxy: Muro FA / Gero+ trasdosado 90 240 (4)
In: Planta baixa
Classification: Muro (Clasificación de ARCHICAD)
1 AMB.Identificacio - 103.AMB.Classificacio: GuBim Class v1.2; 107.AMB.NomTipus: AMB..; 115.AMB.Nivell: Planta baixa; 119.AMB.FaseCreacio: New; 120.AMB.FaseEnderroc: New
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 116.AMB.SeparacioNivell | 201.AMB.EsEstructural
M.6 | 0,06 | Load-Bearing Element
2 x REV 1.2 | 0,00 | Non-Load-Bearing Element
M.6 | 0,00 | Load-Bearing Element

# IfcBuildingElementProxy: Muro FA/ aplacat gelosia 1 40 (28)
